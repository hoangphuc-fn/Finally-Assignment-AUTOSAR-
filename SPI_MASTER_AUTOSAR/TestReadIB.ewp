# IAR project TestReadIB.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: User; SpiDriver; Standard\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: TestReadIB.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group SpiDriver
    SpiDriver/: Spi.c
  group Standard
    Standard/src/: clk.c exti.c gpio.c itc.c lcd.c spi_hw.c tim4.c
  group User
    User/: main.c
